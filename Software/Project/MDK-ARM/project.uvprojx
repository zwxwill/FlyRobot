# Keil uVision project project.uvprojx, settings and files
target 200M (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_OS_FREERTOS
  c include: ..\..\FreeRtos\include;..\..\User;..\..\User\app\inc;..\..\User\bsp\inc;..\..\User\lib\inc;..\..\User\srv\inc;..\..\User\test\inc;..\..\Libraries\CMSIS_CM3\CM3\CoreSupport;..\..\Libraries\CMSIS_CM3\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\FreeRtos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../User/: main.c stm32f10x_it.c
  group User/App
    ../../User/app/src/: app.c app_test.c app_Led.c app_check.c app_sensor.c
  group User/Bsp
    ../../User/bsp/src/: bsp.c bsp_led.c bsp_uart.c bsp_tim.c bsp_tim_pwm.c bsp_spi.c bsp_nrf24l01.c bsp_mpu6050.c bsp_i2c.c
  group User/Lib
    ../../User/lib/src/: lib_math.c lib_filter.c
  group User/Srv
    ../../User/srv/src/: srv_imu.c srv_debug.c srv_sensor.c
  group MDK-ARM
    ../../Libraries/CMSIS_CM3/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS_CM3/CM3/CoreSupport/: core_cm3.c
    ../../User/: system_stm32f10x.c
  group FreeRtos/source
    ../../FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRtos/Ports
    ../../FreeRtos/include/: FreeRTOSConfig.h
    ../../FreeRtos/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRtos/portable/MemMang/: heap_4.c
    ../../FreeRtos/: readme.txt
  group Test
    ../../User/test/src/: test_tim.c test_nrf24l01.c test_mpu6050.c
  group Doc
    ../../Doc/: 01.开发环境说明.txt 02.模板.txt 03.内存管理.txt 04.GPIO分配表.txt 05.任务分配.txt 06.问题点.txt
software components: CMSIS:CORE 5.0.0
